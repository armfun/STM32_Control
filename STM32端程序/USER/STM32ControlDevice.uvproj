# Keil uVision project STM32ControlDevice.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GraduateWork +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\USMART;..\HARDWARE\SPI;..\uIP-APP;..\uIP-1.0\uip;..\uIP-1.0\apps\webserver;..\HARDWARE\ENC28J60;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\ITEMP;..\HARDWARE\DHT11;..\HARDWARE\IRRmote
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c helper.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/IRRmote/: IRRmote.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c
  group uIP-1.0
    ../uIP-1.0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uIP-APP
    ../uIP-APP/: clock-arch.c tapdev.c tcp.c tcp_server.c
